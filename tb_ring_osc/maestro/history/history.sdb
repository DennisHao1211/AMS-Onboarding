<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" historyDataVersion="7" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Oct 3 12:18:42 2026</timestamp>
			<uuid>{76e7d5ec-8670-45f3-ab07-889e643aeeda}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/usr/scratch/hhao40/analog-onboarding-F26/Cadence/Virtuoso/AMS_Onboarding_Hanxiang_Hao/tb_ring_osc/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/nethome/hhao40/simulation/AMS_Onboarding_Hanxiang_Hao/tb_ring_osc/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/AMS_Onboarding_Hanxiang_Hao/tb_ring_osc/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
